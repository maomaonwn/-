# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers;..\Users;..\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../1.Start of a HAL file/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../Users/: stm32f1xx_it.c
    ../Drivers/BSP/: Track.c
  group Drivers/SYSTEM
    ../Drivers/SYSTEM/delay/: delay.c
    ../Drivers/SYSTEM/sys/: sys.c
    ../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
    ../Drivers/BSP/: TRACK.h
